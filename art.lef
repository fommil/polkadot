VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO art
  CLASS BLOCK ;
  FOREIGN art ;
  ORIGIN 0 0 ;
  SIZE 30.000 BY 6.500 ;
  OBS
    LAYER met4 ;
      RECT 0.000 0.000 30.000 6.500 ;
  END
END art
END LIBRARY
